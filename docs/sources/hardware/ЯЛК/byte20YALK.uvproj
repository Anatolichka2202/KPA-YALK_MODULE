# Keil uVision project byte20YALK.uvproj, settings and files
target yalk96-10MHz (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: byte20YALK +hex
  c flags: Optim=1 oTime=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group src
    ./: LPC2300.s main.cpp
    ./my_lib/: Flash.cpp
  group lib
    ./my_lib/: fastport.cpp pinsel.cpp uart.cpp vic.cpp
