# Keil uVision project GD32F303.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: GD32F303CG GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: GD32F303
  c flags: Optim=1
  c include: .\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: startup_gd32f30x_xd.s main.c
